# Keil uVision project toilet-led.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: toilet-led
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\Projects\cmsis;.\Projects\drivers\src;.\Projects\drivers\inc;.\Projects\libraries\inc;.\Projects\libraries\src;.\Projects\startup_codes;.\Projects\users
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group users
    ./Projects/users/: stm32f10x_it.c main.c system_stm32f10x.c
  group drivers
    ./Projects/drivers/src/: driversInit.c led.c systick.c usart.c swtich.c sx1276.C spi.c timer.c schd.c F8L10_LORA.c F8L10_TASK.c
  group libraries
    ./Projects/libraries/src/: misc.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c
  group cmsis
    ./Projects/cmsis/: core_cm3.c
  group startup_codes
    ./Projects/startup_codes/: startup_stm32f10x_md.s
